# Repository miloh/stereopi-kicad-schematic

## KiCad design StereoPi.kicad_pcb

Board: 6 copper layers, 90.0 x 40.0 mm, 187 parts (98 on the bottom side), 141 nets.

Parts:
C1, C2, C20, C30, C64: 1u; C_0402_1005Metric
C3, C7, C12, C17, C22, C34, C35, C50, C102, C103: 10u; C_0805_2012Metric
C4, C8, C9, C13, C18, C19, C33, C38, C41, C42, C52, C56, C58, C61, C76, C77, C80, C85, C104, C105: 10n; C_0402_1005Metric
C5, C6, C10, C11, C14, C15, C16, C21, C36, C39, C40, C43, C45, C46, C48, C49, C51, C55, C60, C63, C69, C70, C71, C72, C78, C79, C81, C82, C83, C84, C88, C91, C93, C94, C96: 100n; C_0402_1005Metric
C23, C24, C26, C27, C28, C29, C37: 22u; C_1206_3216Metric
C25, C32: 470n; C_0603_1608Metric
C31: 2u2; C_0603_1608Metric
C44, C53: 1nF; C_0805_2012Metric
C47: 10u/10V; CP_EIA-3528-15_AVX-H
C62, C92, C95: 4u7; C_0805_2012Metric
C65, C66: 33p; C_0402_1005Metric
C67: 22n; C_0603_1608Metric
D1, D2, D3, D4: SP3003-02; SOT-353_SC-70-5
DA1: TPS70625; SOT-23-5
DD2: LM26420; HTSSOP-20-1EP_4.4x6.5mm_P0.65mm_ThermalPad_Ti
DD3: AP2331SA-7; SOT-23
DD4: FSUBS42UMX; UMLP-10_1.4x1.8x0.5mm_P0.4mm
DD5: ESD5384; WLCSP-9_1.14x1.14mm_P0.4mm
DD6: LAN9513; QFN-64-1EP_9x9mm_P0.5mm
DQ1, DQ2, DQ3, DQ4, DQ5, DQ6: KP-1608SCG; LED_0603_1608Metric
F1: MF-MSMF200-2; Fuse_1812_4532Metric
JP1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
L1, L2: 1uH 4A; L_Bourns-SRN4018
L3, L6: 2A, 120r; L_0603_1608Metric
L4, L7, L8: 1.3A 120r; L_0402_1005Metric
R1, R8, R9, R18, R55, R56: 47k; R_0402_1005Metric
R2, R3, R5, R6, R15, R17, R45: 0r; R_0402_1005Metric
R4, R23, R24: 100k; R_0402_1005Metric
R7: 5r1; R_0402_1005Metric
R10: 31k6; R_0402_1005Metric
R11: 12k7; R_0402_1005Metric
R12, R25, R29, R30, R32, R44: 470r; R_0402_1005Metric
R13, R14: 10k; R_0402_1005Metric
R16, R19, R20, R21, R22, R28, R31, R40, R48, R49, R50, R51, R52, R53, R54: 4k7; R_0402_1005Metric
R26: 12k; R_0402_1005Metric
R27: 12k4; R_0402_1005Metric
R33, R34, R35, R36: 49r9; R_0402_1005Metric
R37: 10r; R_0402_1005Metric
R39: 1M; R_0402_1005Metric
R41: 1M; R_1206_3216Metric
RN42, RN43: 22; R_Array_Concave_4x0402
SW1: SW_SPDT; SK12D07VG3
T1: Pulse_J0011D01BNL; Conn_RJ45_Transformer_LEDs
VD4: SSB44; D_SMB
VT1, VT2, VT3, VT5, VT6: IRML2502TR; SOT-23
VT4: PDTC143ET; SOT-23
XS1: Micro_SD_Card_Det; Conn_uSDcard
XS2: USB_A_double; CON_USB-A_2-port
XS3: HDMI_A; HDMI_A_Female_2000-1-2-41-00-BK
XS4: EH 2pol; JST_EH_B02B-EH-A_1x02_P2.50mm_Vertical
XS5, XS6: FPC 15pol; FPC-15_VERTICAL_2
XS8: USB_B_Micro; USB_Micro-B_Molex-105017-0001
XS9: Conn_01x04; PinHeader_1x04_P2.54mm_Vertical
XS10: Raspberry_Pi_2_3; PinHeader_2x20_P2.54mm_Vertical_SMD
XS11: S0DIMM DDR2 Standard; Conn_TE-DDR2-SODIMM-0.6-200P-doublesided
Y1: 25MHz; Crystal_SMD_Abracon_ABM3B-4Pin_5.0x3.2mm

Connections:
1V8: C13.1, C15.1, C28.1, C29.1, C102.1, C103.1, L2.2, R3.2, R4.1, R6.2, R11.1, R55.1, XS11.183, XS11.184, XS11.185, XS11.186
3V3: C4.1, C5.1, C7.1, C9.1, C12.1, C26.1, C27.1, C30.1, C42.1, C43.1, C45.2, C46.2, C49.1, C52.2, C58.2, C69.1, C70.1, C71.1, C72.1, C76.1, C77.1, C92.1, C93.1, C94.1, C95.1, C104.1, C105.1, DA1.1, DA1.3, DD4.9, DD6.11, DD6.19, DD6.27, DD6.33, DD6.39, DD6.40, DD6.46, DQ1.2, DQ3.2, DQ4.2, DQ5.2, DQ6.2, L1.1, L8.1, R2.2, R5.2, R10.2, R16.1, R17.2, R18.1, R20.1, R21.1, R22.1, R28.1, R31.1, R40.1, R45.2, R48.2, R49.1, R50.1, R52.1, T1.9, T1.12, XS1.4, XS5.15, XS6.15, XS10.1, XS10.17, XS11.4, XS11.6, XS11.191, XS11.192, XS11.193, XS11.194
5VCC: C11.1, C23.1, C24.1, C34.1, C38.1, C39.1, DD2.2, DD2.3, DD2.4, DD2.17, DD2.18, DD2.19, DD3.3, DQ2.2, F1.1, R7.2, R8.2, R9.2, R15.2, XS10.2, XS10.4
5VCC_EXT: C36.1, C37.1, F1.2, L6.1, L7.1, SW1.2, VD4.1
5VCC_HDMI: C40.1, C41.1, C96.2, DD3.2, DD5.A1, DD5.C1, R53.1, R54.1, VT5.1, XS3.18
5V_EXT: SW1.3, XS4.1
+1V8_CORE: C20.1, C60.1, C61.1, C62.1, DD6.15, DD6.38
+1V8_ETH: C63.1, DD6.48, L4.2
+3V3A: C6.1, C16.1, C33.1, C78.1, C79.1, C80.1, C81.1, C82.1, C83.1, C84.1, C85.1, C88.1, C91.1, DD6.5, DD6.10, DD6.49, DD6.51, DD6.54, DD6.57, DD6.64, L8.2, R33.1, R34.1, R35.1, R36.1, R37.1
+5V_USB_BOOT: C47.1, C48.1, JP1.1, L3.1, R19.2, VD4.2, VT3.1
/Main/CAM0_IO0: R24.1, XS6.11, XS11.82
/Main/CAM0_IO1: XS6.12, XS11.66
/Main/CAM0_SCL: R16.2, XS6.13, XS11.5
/Main/CAM0_SDA: R20.2, XS6.14, XS11.3
/Main/CAM1_IO0: R23.1, XS5.11, XS11.84
/Main/CAM1_IO1: XS5.12, XS11.60
/Main/CAM1_SCL: R22.2, XS5.13, XS11.30
/Main/CAM1_SDA: R21.2, XS5.14, XS11.28
/Main/GPIO14_TXD0: XS10.8, XS11.51
/Main/GPIO15_RXD0: XS10.10, XS11.53
/Main/GPIO16: XS10.36, XS11.57
/Main/GPIO17: XS10.11, XS11.59
/Main/GPIO18_PWM0: XS10.12, XS11.63
/Main/GPIO19_MISO1: XS10.35, XS11.65
/Main/GPIO20_MOSI1: XS10.38, XS11.69
/Main/GPIO21_SLCK1: XS10.40, XS11.71
/Main/GPIO22: XS10.15, XS11.75
/Main/GPIO23: XS10.16, XS11.77
/Main/GPIO24: XS10.18, XS11.81
/Main/GPIO25: XS10.22, XS11.83
/Main/GPIO26: XS10.37, XS11.87
/Main/GPIO27: XS10.13, XS11.89
/Main/HDMI_CLK_N: XS3.12, XS11.111
/Main/HDMI_CLK_P: XS3.10, XS11.113
/Main/HDMI_D0_N: XS3.9, XS11.117
/Main/HDMI_D0_P: XS3.7, XS11.119
/Main/HDMI_D1_N: XS3.6, XS11.123
/Main/HDMI_D1_P: XS3.4, XS11.125
/Main/HDMI_D2_N: XS3.3, XS11.129
/Main/HDMI_D2_P: XS3.1, XS11.131
/Main/HDMI_SCL: DD5.A3, R54.2, XS3.15, XS11.175
/Main/HDMI_SDA: DD5.B3, R53.2, XS3.16, XS11.173
/Main/SD_CLK: RN43.1, XS11.10
/Main/SD_CMD: RN42.4, XS11.12
/Main/SD_DAT0: RN43.3, XS11.16
/Main/SD_DAT1: RN43.4, XS11.18
/Main/SD_DAT2: RN42.2, XS11.22
/Main/SD_DAT3: RN42.3, XS11.24
/Main/SD_DETECT: R48.1, XS1.9, XS11.52
/Power/1V8_SW: DD2.16, L2.1
/Power/3V3_SW: DD2.5, L1.2
/Power/EMMC_DISABLE_N: VT1.3, XS11.2
/Power/EMMC_EN_N_1V8: R4.2, VT2.1, XS11.90
/USB LAN/5V_USB0_EXT: C50.1, C51.1, D2.3, D3.3, L7.2, XS2.1, XS2.5
/USB LAN/5V_USB2_EXT: C3.1, C55.1, C56.1, D4.3, L6.2, XS9.1
/USB LAN/5V_USB_BOOT_EXT: D1.3, L3.2, XS8.1
/USB LAN/ETH_RX_N: DD6.53, R36.2, T1.6
/USB LAN/ETH_RX_P: DD6.52, R35.2, T1.3
/USB LAN/ETH_TX_N: DD6.56, R34.2, T1.2
/USB LAN/ETH_TX_P: DD6.55, R33.2, T1.1
/USB LAN/HARD_RESET: C14.1, DD6.12, R31.2, VT4.3
/USB LAN/USB2_N: D2.4, DD6.1, XS2.2
/USB LAN/USB2_P: D2.5, DD6.2, XS2.3
/USB LAN/USB3_N: D3.4, DD6.3, XS2.6
/USB LAN/USB3_P: D3.5, DD6.4, XS2.7
/USB LAN/USB4_N: D4.4, DD6.6, XS9.2
/USB LAN/USB4_P: D4.5, DD6.7, XS9.3
/USB LAN/USB_HSD2_N: DD4.6, DD6.58
/USB LAN/USB_HSD2_P: DD4.7, DD6.59
/USB LAN/USB_HSD_N: D1.4, DD4.4, XS8.2
/USB LAN/USB_HSD_P: D1.5, DD4.5, XS8.3
/USB LAN/VDD18USBPLL: C64.1, DD6.62, L4.1
/USB LAN/nFDX: DD6.20, R29.2
/USB LAN/nFDX_LED: DQ3.1, R29.1
/USB LAN/nLINKA: DD6.21, R30.2
/USB LAN/nLINKA_LED: DQ4.1, R30.1, T1.10
/USB LAN/nSPD: DD6.22, R32.2
/USB LAN/nSPD_LED: DQ5.1, R32.1, T1.11
DAC_2V5: C8.1, C10.1, C17.1, C31.1, C32.1, DA1.5, R45.1, XS11.189, XS11.190
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.1, C46.1, C47.2, C48.2, C49.2, C50.2, C51.2, C52.1, C53.2, C55.2, C56.2, C58.1, C60.2, C61.2, C62.2, C63.2, C64.2, C65.2, C66.2, C67.2, C69.2, C70.2, C71.2, C72.2, C76.2, C77.2, C78.2, C79.2, C80.2, C81.2, C82.2, C83.2, C84.2, C85.2, C88.2, C91.2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
GPIO38_RESET: VT4.1, XS11.64
unnamed: C1.1, R2.1, R3.1, XS11.39, XS11.40
unnamed: C2.1, R5.1, R6.1, XS11.41, XS11.42
unnamed: C25.1, DD2.1, R7.1
unnamed: C65.1, DD6.61, R39.1, Y1.1
unnamed: C66.1, DD6.60, R39.2, Y1.3
unnamed: C67.1, R37.2, T1.4, T1.5
unnamed: DD2.8, R10.1, R13.1
unnamed: DD2.9, R8.1
unnamed: DD2.12, R9.1
unnamed: DD2.13, R11.2, R14.1
unnamed: DD4.1, XS11.165
unnamed: DD4.2, XS11.167
unnamed: DD4.10, R18.2, VT3.3
unnamed: DD5.A2, VT5.3, XS3.13
unnamed: DD5.C3, R56.1, VT6.1, XS3.19
unnamed: DD6.28, DD6.29, DD6.30, DD6.32, R40.2
unnamed: DD6.41, R28.2
unnamed: DD6.50, R27.1
unnamed: DD6.63, R26.1
unnamed: DQ1.1, R12.2
unnamed: DQ2.1, R25.2
unnamed: DQ6.1, R44.1
unnamed: JP1.2, R1.1, VT1.1
unnamed: R44.2, VT1.2, VT2.3
unnamed: R49.2, XS10.3, XS11.9
unnamed: R50.2, XS10.5, XS11.11
unnamed: R51.2, XS11.168
unnamed: R52.2, VT5.2, XS11.171
unnamed: R55.2, VT6.3, XS11.88
unnamed: RN42.5, XS1.3
unnamed: RN42.6, XS1.2
unnamed: RN42.7, XS1.1
unnamed: RN43.5, XS1.8
unnamed: RN43.6, XS1.7
unnamed: RN43.8, XS1.5
unnamed: XS10.7, XS11.15
unnamed: XS10.19, XS11.33
unnamed: XS10.21, XS11.29
unnamed: XS10.23, XS11.35
unnamed: XS10.24, XS11.27
unnamed: XS10.26, XS11.23
unnamed: XS10.29, XS11.17
unnamed: XS10.31, XS11.21
unnamed: XS10.32, XS11.45
unnamed: XS10.33, XS11.47
unnamed: XS6.3, XS11.136
unnamed: XS6.2, XS11.138
unnamed: XS6.9, XS11.142
unnamed: XS6.8, XS11.144
unnamed: XS5.9, XS11.147
unnamed: XS6.6, XS11.148
unnamed: XS5.8, XS11.149
unnamed: XS6.5, XS11.150
unnamed: XS5.6, XS11.153
unnamed: XS5.5, XS11.155
unnamed: XS5.3, XS11.159
unnamed: XS5.2, XS11.161
SHELF1_GND: C44.1, D1.2, XS8.6
SHELF_GND: C53.1, D2.2, D3.2, R41.1, T1.8, T1.13, XS2.9
VBAT: C18.1, C19.1, C21.1, C22.1, C35.1, R15.1, R17.1, XS11.197, XS11.198, XS11.199, XS11.200

## Commit log

2021-01-25 remove solder_paste_margin_ratio expressions, edit justify to remove bottom arguments for temporary io
